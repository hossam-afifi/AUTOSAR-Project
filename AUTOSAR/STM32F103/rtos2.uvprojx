# Keil uVision project rtos2.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtos2
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c can_app.c can_app.h helper.c
  group commstack
    ./: Can.c Can.h Can_Cfg.h CanIf.c CanIf_Cfg.h CanIf_Cbk.h CanIf.h CanIf_Types.h CanIf_SpecialPdus.h CanIf_ConfigTypes.h CanTp.c CanTp_Types.h CanTp_Cfg.h CanTp_Cbk.h CanTp.h asdebug.h cpu.h Det.h Det_Cfg.h MCU.h Modules.h Platform_types.h ringbuffer.h std_type.h PduR.c PduR.h PduR_CanIf.c PduR_CanIf.h PduR_CanTp.c PduR_CanTp.h PduR_Cfg.h PduR_Com.c PduR_Com.h PduR_If.h PduR_Types.h ComStack_Types.h PduR_PbCfg.h
software components: RTOS:Config 10.3.1, RTOS:Core 10.3.1, RTOS:Event Groups 10.3.1, RTOS:Heap 10.3.1, RTOS:Timers 10.3.1, CMSIS:CORE 5.4.0, CMSIS:RTOS2:FreeRTOS 10.3.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:CAN 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0
